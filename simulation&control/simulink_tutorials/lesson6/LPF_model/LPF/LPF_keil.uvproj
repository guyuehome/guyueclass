# Keil uVision project LPF_keil.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LPF_keil +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c LPF.c LPF_data.c rt_nonfinite.c rtGetInf.c rtGetNaN.c
